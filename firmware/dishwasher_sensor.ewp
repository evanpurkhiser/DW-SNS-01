# IAR project dishwasher_sensor.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG24B220F1536IM48 SiliconLaboratories EFR32MG24B220F1536IM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: EFR32MG24B220F1536IM48=1; SL_CODE_COMPONENT_SYSTEM=system; SL_APP_PROPERTIES=1; SL_BOARD_NAME="BRD4187C"; SL_BOARD_REV="A01"; HARDWARE_BOARD_DEFAULT_RF_BAND_2400=1; HARDWARE_BOARD_SUPPORTS_1_RF_BAND=1; HARDWARE_BOARD_SUPPORTS_RF_BAND_2400=1; HFXO_FREQ=39000000; SL_CODE_COMPONENT_BYTE_UTILITIES=byte_utilities; SL_CODE_COMPONENT_CLOCK_MANAGER=clock_manager; CUSTOM_TOKEN_HEADER="sl_token_manager_af_token_header.h"; SL_TOKEN_MANAGER_BACKEND_INT_FLASH=1; SL_COMMON_TOKEN_MANAGER_ENABLE_DYNAMIC_TOKENS=1; SL_COMMON_TOKEN_MANAGER_ENABLE_STATIC_TOKENS=1; SL_COMPONENT_CATALOG_PRESENT=1; SL_CODE_COMPONENT_DEVICE_PERIPHERAL=device_peripheral; SL_CODE_COMPONENT_DMADRV=dmadrv; SL_CODE_COMPONENT_GPIO=gpio; SL_CODE_COMPONENT_HAL_COMMON=hal_common; SL_CODE_COMPONENT_HAL_GPIO=hal_gpio; SL_CODE_COMPONENT_HAL_SYSRTC=hal_sysrtc; SL_CODE_COMPONENT_INTERRUPT_MANAGER=interrupt_manager; CMSIS_NVIC_VIRTUAL=1; CMSIS_NVIC_VIRTUAL_HEADER_FILE="cmsis_nvic_virtual.h"; SL_CODE_COMPONENT_LEGACY_HAL=legacy_hal; CORTEXM3=1; CORTEXM3_EFM32_MICRO=1; CORTEXM3_EFR32=1; PHY_RAIL=1; PLATFORM_HEADER="platform-header.h"; SL_LEGACY_HAL_ENABLE_WATCHDOG=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; SL_CODE_COMPONENT_POWER_MANAGER=power_manager; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_CODE_COMPONENT_RAIL_UTIL_IEEE802154_PHY_SELECT=rail_util_ieee802154_phy_select; SL_CODE_COMPONENT_RAIL_UTIL_IEEE802154_STACK_EVENT=rail_util_ieee802154_stack_event; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; SL_CODE_COMPONENT_SE_MANAGER=se_manager; SL_CODE_COMPONENT_CORE=core; SL_RAIL_3_API=1; SL_CODE_COMPONENT_SLEEPTIMER=sleeptimer; SL_CODE_COMPONENT_PSEC_OSAL=psec_osal; SL_ZIGBEE_LEAF_STACK=1; SL_CODE_COMPONENT_BUFFER_MANAGER=buffer_manager; SL_CODE_COMPONENT_IEEE_802_15_4_MAC=ieee_802_15_4_mac; SL_CODE_COMPONENT_ZIGBEE_STACK=zigbee_stack; SL_ZIGBEE_MULTI_NETWORK_STRIPPED=1; SL_ZIGBEE_PHY_SELECT_STACK_SUPPORT=1; SL_ZIGBEE_STACK_COMPLIANCE_REVISION=22; STACK_CORE_HEADER="stack/core/sl_zigbee_stack.h"; STACK_HEADER="stack/include/sl_zigbee.h"; STACK_TYPES_HEADER="stack/include/sl_zigbee_types.h"; CONFIGURATION_HEADER="app/framework/util/config.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; autogen; config; config\prioconf; config\zcl; src; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\Device\SiliconLabs\EFR32MG24\Include; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\common\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\hardware\board\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\bootloader; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\bootloader\api; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\bootloader\core\flash; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\util\plugin\byte_utilities; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\cli\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\cli\src; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\clock_manager\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\clock_manager\src; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\CMSIS\Core\Include; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\token_manager\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\token_manager\src; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\token_manager\legacy\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\hardware\driver\configuration_over_swo\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\driver\debug\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\device_manager\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\device_init\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\emdrv\dmadrv\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\emdrv\dmadrv\inc\s2_signals; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\emdrv\common\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\emlib\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\driver\gpio\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\peripheral\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\hfxo_manager\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\interrupt_manager\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\interrupt_manager\src; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\interrupt_manager\inc\arm; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\iostream\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\legacy_hal\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\legacy_hal_wdog\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\security\sl_component\sl_mbedtls_support\config; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\security\sl_component\sl_mbedtls_support\config\preset; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\security\sl_component\sl_mbedtls_support\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\util\third_party\mbedtls\include; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\util\third_party\mbedtls\library; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\memory_manager\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\memory_manager\src; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\hardware\driver\mx25_flash_shutdown\inc\sl_mx25_flash_shutdown_eusart; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\emdrv\nvm3\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\emdrv\nvm3\config; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\power_manager\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\util\third_party\printf; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\util\third_party\printf\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\security\sl_component\sl_psa_driver\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\common; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\protocol\ble; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\protocol\ieee802154; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\protocol\wmbus; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\protocol\zwave; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\protocol\sidewalk; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\plugin\rail_util_built_in_phys\efr32xg24; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\plugin\rail_util_ieee802154; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\plugin\pa-conversions; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\plugin\pa-conversions\efr32xg24; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\plugin\rail_util_power_manager_init; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\plugin\rail_util_pti; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\security\sl_component\se_manager\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\util\plugin\security_manager; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\sl_main\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\sl_main\src; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\sleeptimer\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\security\sl_component\sli_psec_osal\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\service\udelay\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\plugin\basic; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\util\serial; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\service-function; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\stack\framework; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\plugin\debug-print; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\plugin\end-device-support; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\plugin\network-steering; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\plugin\reporting; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\plugin\scan-dispatch; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\stack\security; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\stack\include; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\stack\internal\inc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\signature-decode; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\rail_lib\plugin; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\util\counters; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\stack; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\stack\zigbee; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\mac\rail_mux; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\platform\radio\mac; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\util\silicon_labs\silabs_core; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\stack\core; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\stack\mac; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\stack\routing\zigbee; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\em260; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\stack\internal\src\ipc; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\common; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\plugin\update-tc-link-key; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\include; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\util; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\security; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\util\zigbee-framework; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\framework\cli; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\util\common; ..\.silabs-home\.silabs\slt\installs\conan\p\simpleb526998f4a4d\p\protocol\zigbee\app\util\security
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dishwasher_sensor.s37
  ILINK.IlinkOutputFile: dishwasher_sensor.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: dishwasher_sensor.ipcf
